Commit message: fix

File: catkin_ws/src/realsense_tower/urdf/description.urdf (robot description, URDF)
Before this commit: robot realsense_tower, 4 links, 3 joints
Joints:
- joint middle_joint: origin xyz=0.11049 0  0.02428 rpy=0 0 0 -> xyz=0.11049 0.035 0.02428 rpy=0 0 0
